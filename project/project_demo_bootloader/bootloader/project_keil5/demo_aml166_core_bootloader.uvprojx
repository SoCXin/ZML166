# Keil uVision project demo_aml166_core_bootloader.uvprojx, settings and files
target debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ZLG116 Generic
  pack: ZLG.ZLG100_DFP.1.0.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: example_aml166_core +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M0
  c include: ..\user_code;..\user_config;..\user_config/am_hwconf_usrcfg;..\user_config/am_servconf_usrcfg;..\..\..\..\..\3rdparty/CMSIS/Include;..\..\..\..\..\arch/arm/include;..\..\..\..\..\board/bsp_common/include;..\..\..\..\..\components/drivers/include;..\..\..\..\..\components/libc/armlib_adapter/include;..\..\..\..\..\components/libc/microlib_adapter/include;..\..\..\..\..\components/service/include;..\..\..\..\..\components/util/include;..\..\..\..\..\examples/board/am116_core;..\..\..\..\..\examples/components;..\..\..\..\..\examples/soc/zlg;..\..\..\..\..\examples/std;..\..\..\..\..\interface;..\..\..\..\..\soc/zlg/zlg116;..\..\..\..\..\soc/zlg/drivers/include/adc;..\..\..\..\..\soc/zlg/drivers/include/bkp;..\..\..\..\..\soc/zlg/drivers/include/clk;..\..\..\..\..\soc/zlg/drivers/include/cmp;..\..\..\..\..\soc/zlg/drivers/include/crc;..\..\..\..\..\soc/zlg/drivers/include/dac;..\..\..\..\..\soc/zlg/drivers/include/dma;..\..\..\..\..\soc/zlg/drivers/include/exti;..\..\..\..\..\soc/zlg/drivers/include/flash;..\..\..\..\..\soc/zlg/drivers/include/gpio;..\..\..\..\..\soc/zlg/drivers/include/i2c;..\..\..\..\..\soc/zlg/drivers/include/pwr;..\..\..\..\..\soc/zlg/drivers/include/rcc;..\..\..\..\..\soc/zlg/drivers/include/spi;..\..\..\..\..\soc/zlg/drivers/include/syscfg;..\..\..\..\..\soc/zlg/drivers/include/tim;..\..\..\..\..\soc/zlg/drivers/include/uart;..\..\..\..\..\soc/zlg/drivers/include/wdt;..\..\..\..\..\examples\board\am166_core;..\..\..\..\..\examples\components\bootloader;..\..\..\..\..\components\bootloader\include\arch\arm;..\..\..\..\..\components\bootloader\include\core;..\..\..\..\..\components\bootloader\include\drivers;..\user_config\am_bootconf_usrcfg;..\..\..\..\..\soc\zlg\drivers\include\bootloader;..\..\..\..\..\soc\zlg\drivers\include\device\hw
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group bsp_common
    ../../../../bsp_common/source/: am_bsp_armlib.c am_bsp_delay_timer.c am_bsp_isr_defer_pendsv.c am_bsp_microlib.c am_bsp_system_heap.c
  group arm
    ../../../../../arch/arm/source/: am_arm_nvic.c am_arm_nvic_armcc.s am_arm_systick.c
  group drivers
    ../../../../../components/drivers/source/zlg600/: am_zlg600.c
    ../../../../../components/drivers/source/adc/: am_cs1237.c
    ../../../../../components/drivers/source/ble/: am_zlg9021.c
    ../../../../../components/drivers/source/buzzer/: am_buzzer_pwm.c
    ../../../../../components/drivers/source/digitron/com/: am_digitron_com_gpio.c
    ../../../../../components/drivers/source/digitron/seg/: am_digitron_seg_gpio.c am_digitron_seg_hc595.c
    ../../../../../components/drivers/source/digitron/: am_digitron_scan_gpio.c am_digitron_scan_hc595_gpio.c
    ../../../../../components/drivers/source/digitron_key/: am_zlg72128_std.c zlg72128.c zlg72128_platform.c
    ../../../../../components/drivers/source/fingerprint/: am_ts10x.c
    ../../../../../components/drivers/source/flash/: am_mx25xx.c
    ../../../../../components/drivers/source/hc595/: am_hc595_gpio.c am_hc595_spi.c
    ../../../../../components/drivers/source/i2c/: am_i2c_gpio.c
    ../../../../../components/drivers/source/key/: am_key_gpio.c am_key_matrix_gpio.c am_key_matrix_prepare_gpio.c am_key_matrix_read_gpio.c
    ../../../../../components/drivers/source/led/: am_led_hc595.c am_led_gpio.c
    ../../../../../components/drivers/source/miniport/: am_miniport_view_key_595.c am_miniport_view_key.c
    ../../../../../components/drivers/source/nvram/: am_ep24cxx.c
    ../../../../../components/drivers/source/rtc/: am_ds1302.c am_pcf85063.c am_rx8025sa.c am_rx8025t.c
    ../../../../../components/drivers/source/sht20/: am_sht20.c
    ../../../../../components/drivers/source/spi/: am_spi_gpio.c
    ../../../../../components/drivers/source/temperature/: am_temp_lm75.c
    ../../../../../components/drivers/source/uart/: am_sc16is7xx.c
    ../../../../../components/drivers/source/fm175xx/: am_fm175xx_zlg116.lib
    ../../../../../components/drivers/source/sensor/: am_sensor_hts221.c
    ../../../../../components/drivers/source/pt100/: am_pt100_to_temperature.c
    ../../../../../components/drivers/source/thermocouple/: am_thermocouple.c
  group libc
    ../../../../../components/libc/armlib_adapter/source/: am_armlib_adapter.c
    ../../../../../components/libc/microlib_adapter/source/: am_microlib_adapter.c
  group service
    ../../../../../components/service/source/: am_adc.c am_buzzer_dev.c am_dac.c am_digitron_dev.c am_digitron_scan.c am_digitron_seg8_ascii.c am_event.c am_event_category_input.c am_event_input_key.c am_ftl.c am_i2c.c am_i2c_slv_subaddr.c am_key_matrix.c am_key_matrix_softimer.c am_led_dev.c am_mtd.c am_nvram.c am_spi.c am_system.c am_time.c am_uart.c am_uart_rngbuf.c am_timer.c am_sensor.c
  group util
    ../../../../../components/util/source/: am_isr_defer.c am_jobq.c am_koutput.c am_kprintf.c am_memheap.c am_rngbuf.c am_snprintf.c am_softimer.c am_vdebug.c am_vfprintf_do.c am_vsnprintf.c am_wait.c
  group soc
    ../../../../../soc/zlg/drivers/source/adc/: am_zlg_adc.c
    ../../../../../soc/zlg/drivers/source/clk/: am_zlg116_clk.c
    ../../../../../soc/zlg/drivers/source/crc/: am_zlg_crc.c
    ../../../../../soc/zlg/drivers/source/dac/: am_zlg_dac.c
    ../../../../../soc/zlg/drivers/source/dma/: am_zlg_dma.c
    ../../../../../soc/zlg/drivers/source/flash/: am_zlg_flash.c
    ../../../../../soc/zlg/drivers/source/gpio/: am_zlg116_gpio.c
    ../../../../../soc/zlg/drivers/source/i2c/: am_zlg_i2c_slv.c am_zlg_i2c.c
    ../../../../../soc/zlg/drivers/source/pwr/: am_zlg116_pwr.c
    ../../../../../soc/zlg/drivers/source/rcc/hw/: amhw_zlg116_rcc.c
    ../../../../../soc/zlg/drivers/source/spi/: am_zlg_spi_dma.c am_zlg_spi_int.c am_zlg_spi_slv_dma.c am_zlg_spi_poll.c
    ../../../../../soc/zlg/drivers/source/tim/: am_zlg_tim_pwm.c am_zlg_tim_cap.c am_zlg_tim_timing.c
    ../../../../../soc/zlg/drivers/source/uart/hw/: amhw_zlg_uart.c
    ../../../../../soc/zlg/drivers/source/uart/: am_zlg_uart.c
    ../../../../../soc/zlg/drivers/source/wdt/: am_zlg_iwdg.c am_zlg_wwdg.c
    ../../../../../soc/zlg/zml166/adc/: am_zml166_adc.lib
    ../../../../../soc/zlg/drivers/source/bootloader/: am_zlg_boot_flash.c
  group examples_board
    ../../../../../examples/board/am166_core/buzzer/: demo_aml166_core_std_buzzer.c
    ../../../../../examples/board/am166_core/delay/: demo_aml166_core_std_delay.c
    ../../../../../examples/board/am166_core/dma/: demo_aml166_core_drv_dma_m2m.c
    ../../../../../examples/board/am166_core/flash/: demo_aml166_core_drv_flash.c
    ../../../../../examples/board/am166_core/gpio/: demo_aml166_core_hw_gpio.c demo_aml166_core_hw_gpio_trigger.c demo_aml166_core_std_gpio.c demo_aml166_core_std_gpio_trigger.c
    ../../../../../examples/board/am166_core/i2c/: demo_aml166_core_hw_i2c_master_poll.c demo_aml166_core_hw_i2c_slave_poll.c demo_aml166_core_std_i2c_lm75.c demo_aml166_core_std_i2c_master_async.c demo_aml166_core_std_i2c_master_sync.c demo_aml166_core_std_i2c_slave.c demo_aml166_core_std_i2c_slave_subaddr.c
    ../../../../../examples/board/am166_core/input_event/: demo_aml166_core_std_input_event.c
    ../../../../../examples/board/am166_core/led/: demo_aml166_core_std_led.c
    ../../../../../examples/board/am166_core/microport_board/: demo_aml166_core_microport_ds1302.c demo_aml166_core_microport_eeprom.c demo_aml166_core_microport_eeprom_nvram.c demo_aml166_core_microport_flash.c demo_aml166_core_microport_flash_ftl.c demo_aml166_core_microport_flash_mtd.c demo_aml166_core_microport_rs485.c demo_aml166_core_microport_rtc.c demo_aml166_core_microport_rx8025t.c demo_aml166_core_microport_usb.c
    ../../../../../examples/board/am166_core/miniport_board/: demo_aml166_core_miniport_digitron.c demo_aml166_core_miniport_hc595_digitron.c demo_aml166_core_miniport_hc595_digitron_key.c demo_aml166_core_miniport_hc595_digitron_temp.c demo_aml166_core_miniport_hc595_led.c demo_aml166_core_miniport_key.c demo_aml166_core_miniport_key_digitron.c demo_aml166_core_miniport_led.c demo_aml166_core_miniport_zlg72128.c
    ../../../../../examples/board/am166_core/softimer/: demo_aml166_core_std_softimer.c
    ../../../../../examples/board/am166_core/spi/: demo_aml166_core_hw_spi_master.c demo_aml166_core_std_spi_flash_dma.c demo_aml166_core_std_spi_flash_int.c demo_aml166_core_std_spi_master_dma.c demo_aml166_core_std_spi_master_int.c demo_aml166_core_std_spi_slave_dma.c
    ../../../../../examples/board/am166_core/timer/: demo_aml166_core_hw_tim_cap.c demo_aml166_core_hw_tim_pwm.c demo_aml166_core_hw_tim_timing.c demo_aml166_core_std_tim1_cap.c demo_aml166_core_std_tim1_pwm.c demo_aml166_core_std_tim1_timing.c demo_aml166_core_std_tim2_cap.c demo_aml166_core_std_tim2_pwm.c demo_aml166_core_std_tim2_timing.c demo_aml166_core_std_tim3_cap.c demo_aml166_core_std_tim3_pwm.c demo_aml166_core_std_tim3_timing.c demo_aml166_core_std_tim16_timing.c demo_aml166_core_std_tim17_timing.c
    ../../../../../examples/board/am166_core/uart/: demo_aml166_core_hw_uart_int.c demo_aml166_core_hw_uart_polling.c demo_aml166_core_hw_uart_rx_dma.c demo_aml166_core_hw_uart_tx_dma.c demo_aml166_core_std_uart_polling.c demo_aml166_core_std_uart_ringbuf.c
    ../../../../../examples/board/am166_core/wakeup/: demo_aml166_core_drv_sleepmode_timer_wake_up.c demo_aml166_core_drv_sleepmode_wake_up.c demo_aml166_core_drv_standbymode_wake_up.c demo_aml166_core_drv_stopmode_wake_up.c
    ../../../../../examples/board/am166_core/wdg/: demo_aml166_core_hw_iwdg.c demo_aml166_core_hw_wwdg.c demo_aml166_core_std_iwdg.c demo_aml166_core_std_wwdg.c
    ../../../../../examples/board/am166_core/: demo_aml166_core_entries.h
    ../../../../../examples/board/am166_core/adc/: demo_aml166_core_zml166_adc_pt100_measure.c demo_aml166_core_zml166_adc_thermocouple_measure.c demo_aml166_core_zml166_adc_vol_measure.c demo_aml166_core_zml166_adc_vol_para_adjuet.c
    ../../../../../examples/board/am166_core/bootloader/: demo_aml166_core_single_uart_bootloader.c
  group examples_components
    ../../../../../examples/components/drivers/: demo_ep24cxx.c demo_mx25xx.c demo_fm175xx_picca_read_id.c demo_fm175xx_picca_lpcd_read_id.c demo_fm175xx_picca_halt.c demo_fm175xx_picca_read_block.c demo_fm175xx_picca_val_operate.c demo_fm175xx_picca_write_block.c demo_fm175xx_piccb_read_id.c demo_fm175xx_cpu_card.c
    ../../../../../examples/components/service/: demo_ftl.c demo_mtd.c
  group examples_soc
    ../../../../../examples/soc/zlg/adc/: demo_zlg_hw_adc_int.c demo_zml166_adc_pt100_measure.c demo_zml166_adc_thermocouple_measure.c demo_zml166_adc_vol_measure.c demo_zml166_adc_vol_para_adjuet.c
    ../../../../../examples/soc/zlg/dma/: demo_zlg_drv_dma_m2m.c
    ../../../../../examples/soc/zlg/flash/: demo_zlg_drv_flash.c
    ../../../../../examples/soc/zlg/gpio/: demo_zlg_hw_gpio.c demo_zlg_hw_gpio_trigger.c
    ../../../../../examples/soc/zlg/i2c/: demo_zlg_hw_i2c_master_poll.c demo_zlg_hw_i2c_slave_poll.c
    ../../../../../examples/soc/zlg/spi/: demo_zlg_hw_spi_master.c
    ../../../../../examples/soc/zlg/timer/: demo_zlg_hw_tim_cap.c demo_zlg_hw_tim_cmp_toggle.c demo_zlg_hw_tim_pwm.c demo_zlg_hw_tim_pwm_dead.c demo_zlg_hw_tim_timing.c
    ../../../../../examples/soc/zlg/uart/: demo_zlg_hw_uart_int.c demo_zlg_hw_uart_polling.c demo_zlg_hw_uart_rx_dma.c demo_zlg_hw_uart_tx_dma.c
    ../../../../../examples/soc/zlg/wakeup/: demo_zlg116_drv_sleepmode_timer_wake_up.c demo_zlg116_drv_sleepmode_wake_up.c demo_zlg116_drv_standbymode_wake_up.c demo_zlg116_drv_stopmode_wake_up.c
    ../../../../../examples/soc/zlg/wdg/: demo_zlg_hw_iwdg.c demo_zlg_hw_wwdg.c
    ../../../../../examples/soc/zlg/clk/: demo_zlg_hw_clk.c
  group examples_std
    ../../../../../examples/std/adc/: demo_std_adc.c demo_std_adc_ntc.c
    ../../../../../examples/std/buzzer/: demo_std_buzzer.c
    ../../../../../examples/std/cap/: demo_std_timer_cap.c
    ../../../../../examples/std/crc/: demo_std_crc.c
    ../../../../../examples/std/delay/: demo_std_delay.c
    ../../../../../examples/std/gpio/: demo_std_gpio.c demo_std_gpio_trigger.c
    ../../../../../examples/std/i2c/: demo_std_i2c_lm75.c demo_std_i2c_master_async.c demo_std_i2c_master_sync.c demo_std_i2c_slave.c demo_std_i2c_slave_subaddr.c
    ../../../../../examples/std/led/: demo_std_led.c demo_std_led_water_light.c
    ../../../../../examples/std/pwm/: demo_std_timer_pwm.c
    ../../../../../examples/std/softimer/: demo_std_softimer.c
    ../../../../../examples/std/spi/: demo_std_spi_flash.c demo_std_spi_master.c demo_std_spi_slave.c
    ../../../../../examples/std/timer/: demo_std_timer_timing.c
    ../../../../../examples/std/uart/: demo_std_uart_polling.c demo_std_uart_ringbuf.c demo_std_uart_rs485.c
    ../../../../../examples/std/wdt/: demo_std_wdt.c
    ../../../../../examples/std/rtc/: demo_std_rtc.c
    ../../../../../examples/std/input/: demo_std_4key.c demo_std_key.c demo_std_key_digitron.c demo_std_key_digitron_rngbuf.c
    ../../../../../examples/std/hc595/: demo_std_hc595_led.c
    ../../../../../examples/std/digitron/: demo_std_digitron_60s_counting.c demo_std_digitron_temp.c
    ../../../../../examples/std/nvram/: demo_std_nvram.c
    ../../../../../examples/std/sensor/hts221/: demo_std_hts221.c demo_std_hts221_int.c
    ../../../../../examples/components/bootloader/: demo_std_single_bootloader.c
  group startup
    ../startup/: am_aml166_armcc_startup.s
  group user_code
    ../user_code/: main.c
  group user_config
    ../user_config/am_hwconf_usrcfg/: am_hwconf_arm_nvic.c am_hwconf_buzzer_pwm.c am_hwconf_debug_uart.c am_hwconf_fm175xx.c am_hwconf_key_gpio.c am_hwconf_led_gpio.c am_hwconf_lm75.c am_hwconf_microport_ds1302.c am_hwconf_microport_eeprom.c am_hwconf_microport_flash.c am_hwconf_microport_rs485.c am_hwconf_microport_rtc.c am_hwconf_microport_rx8025t.c am_hwconf_miniport_595.c am_hwconf_miniport_key.c am_hwconf_miniport_led.c am_hwconf_miniport_view.c am_hwconf_miniport_view_key.c am_hwconf_miniport_zlg72128.c am_hwconf_sensor_hts221.c am_hwconf_system_tick_softimer.c am_hwconf_aml166_clk.c am_hwconf_aml166_dma.c am_hwconf_aml166_gpio.c am_hwconf_aml166_i2c.c am_hwconf_aml166_i2c_slv.c am_hwconf_aml166_iwdg.c am_hwconf_aml166_pwr.c am_hwconf_aml166_spi_dma.c am_hwconf_aml166_spi_int.c am_hwconf_aml166_spi_slv_dma.c am_hwconf_aml166_systick.c am_hwconf_aml166_tim_cap.c am_hwconf_aml166_tim_pwm.c am_hwconf_aml166_tim_timing.c am_hwconf_aml166_uart.c am_hwconf_aml166_wwdg.c am_hwconf_zml166_adc.c am_hwconf_buzzer_pwm.h am_hwconf_debug_uart.h am_hwconf_fm175xx.h am_hwconf_key_gpio.h am_hwconf_led_gpio.h am_hwconf_lm75.h am_hwconf_microport.h am_hwconf_miniport_595.h am_hwconf_miniport_key.h am_hwconf_miniport_led.h am_hwconf_miniport_view.h am_hwconf_miniport_view_key.h am_hwconf_miniport_zlg72128.h am_hwconf_sensor_hts221.h am_hwconf_system_tick_softimer.h am_hwconf_aml166_spi_poll.c
    ../user_config/: am_board.c am_prj_config.c am_prj_config.h am_board.h
    ../user_config/am_servconf_usrcfg/: am_servconf_event_input.c am_servconf_nvram.c am_service_inst_init.h
    ../user_config/am_bootconf_usrcfg/: am_bootconf_aml166_clk.c am_bootconf_aml166_single.c
  group bootloader
    ../../../../../components/bootloader/source/arch/arm/: am_arm_boot.c
    ../../../../../components/bootloader/source/drivers/: am_boot.c am_boot_enter_check_key.c am_boot_enter_check_uart.c am_boot_enter_check_uart_cmd.c am_boot_firmware_flash.c am_boot_firmware_recv_uart.c am_boot_mem_flash.c am_boot_msg_flag.c am_boot_serial_uart.c
target release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ZLG116 Generic
  pack: ZLG.ZLG100_DFP.1.0.1
  cpu: as above
  output: template_am116_core +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M0
  c include: ..\user_code;..\user_config;..\user_config/am_hwconf_usrcfg;..\user_config/am_servconf_usrcfg;..\..\..\..\..\3rdparty/CMSIS/Include;..\..\..\..\..\arch/arm/include;..\..\..\..\..\board/bsp_common/include;..\..\..\..\..\components/drivers/include;..\..\..\..\..\components/libc/armlib_adapter/include;..\..\..\..\..\components/libc/microlib_adapter/include;..\..\..\..\..\components/service/include;..\..\..\..\..\components/util/include;..\..\..\..\..\examples/board/am116_core;..\..\..\..\..\examples/components;..\..\..\..\..\examples/soc/zlg;..\..\..\..\..\examples/std;..\..\..\..\..\interface;..\..\..\..\..\soc/zlg/zlg116;..\..\..\..\..\soc/zlg/drivers/include/adc;..\..\..\..\..\soc/zlg/drivers/include/bkp;..\..\..\..\..\soc/zlg/drivers/include/clk;..\..\..\..\..\soc/zlg/drivers/include/cmp;..\..\..\..\..\soc/zlg/drivers/include/crc;..\..\..\..\..\soc/zlg/drivers/include/dac;..\..\..\..\..\soc/zlg/drivers/include/dma;..\..\..\..\..\soc/zlg/drivers/include/exti;..\..\..\..\..\soc/zlg/drivers/include/flash;..\..\..\..\..\soc/zlg/drivers/include/gpio;..\..\..\..\..\soc/zlg/drivers/include/i2c;..\..\..\..\..\soc/zlg/drivers/include/pwr;..\..\..\..\..\soc/zlg/drivers/include/rcc;..\..\..\..\..\soc/zlg/drivers/include/spi;..\..\..\..\..\soc/zlg/drivers/include/syscfg;..\..\..\..\..\soc/zlg/drivers/include/tim;..\..\..\..\..\soc/zlg/drivers/include/uart;..\..\..\..\..\soc/zlg/drivers/include/wdt
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
